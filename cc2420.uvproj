# Keil uVision project cc2420.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S3748 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: cc2420
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./: Startup.s os_cpu_asm.asm main.c cc2420.c mod.c common.c random.c stack.c string.c stinger.c hal.c msg.c user.c timer.c signal.c cpu.c power.c pool.c tree.c slot.c
  group lib
    ./driverlib/: driverlib.lib utils.lib
